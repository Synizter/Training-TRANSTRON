# Keil uVision project STM32-BASIC_GPIO.uvprojx, settings and files
target STM32L152-DISC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-BASIC_GPIO
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L152xB
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l152xb.s
  group Drivers/STM32l1xx_HAL_Driver
    ../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_rcc.c stm32l1xx_hal_pwr.c stm32l1xx_hal_gpio.c stm32l1xx_hal_cortex.c stm32l1xx_hal.c stm32l1xx_hal_pwr_ex.c
  group Application/User
    ../Src/: stm32l1xx_hal_msp.c stm32l1xx_it.c main.c
